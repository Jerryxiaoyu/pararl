Commit message: add kinova vel control

File: otter/gym/bullet/assets/table/table.urdf (robot description, URDF)
Before this commit: robot table.urdf, 1 links, 0 joints
Links:
- link baseLink: mass None -> 0.15
